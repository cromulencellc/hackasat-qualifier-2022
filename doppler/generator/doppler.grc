options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: doppler
    output_language: python
    run_options: run
    title: doppler.grc
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: freq_shift
  id: variable
  parameters:
    value: '0'
  states: {}
- name: hdr_1
  id: variable_header_format_default
  parameters:
    access_code: '"00010001000100010001000100010001"'
    bps: '2'
    threshold: '0'
  states: {}
- name: hdr_2
  id: variable_header_format_default
  parameters:
    access_code: '"00011010110011111111110000011101"'
    bps: '2'
    threshold: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: path_loss
  id: variable
  parameters:
    value: '0'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate*100
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: baud_rate/sps
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sat_downlink_120ksps.iq
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: pkt_not_the_data.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: pkt_there_b_a_flag.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: flag.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: freq_shift
    sample_rate: samp_rate
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: '750'
    type: byte
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_shift
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: path_loss
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: path_loss
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/baud_rate)
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (156*2, 70)
    type: byte
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (100,500*(156*2+70))
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 44*1
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 38*1
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_2
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '20'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0_1_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0_1_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0_1_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0x55]'
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_protocol_formatter_bb_0_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_1
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_2
    len_tag_key: '"packet_len"'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baud_rate*2.2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_iq
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: tx_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: tx_data
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_head_0_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_add_xx_0, '0']
- [blocks_head_0_0, '0', blocks_stream_to_tagged_stream_0_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repeat_0, '0', low_pass_filter_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_stream_mux_0_0, '0', virtual_sink_0_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0_0_0_1_0, '1']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0_0_1_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0_0_1_0_0, '0']
- [blocks_stream_to_tagged_stream_0_2, '0', blocks_tagged_stream_mux_0_0_0_1_0_0, '1']
- [blocks_tagged_stream_mux_0_0_0_1, '0', blocks_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0_0_0_1_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0_0_0_1_0_0, '0', digital_crc32_bb_0_1, '0']
- [blocks_tagged_stream_mux_0_0_0_1_1, '0', blocks_stream_mux_0, '1']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_repeat_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0_0_0_1, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0_0_0, '0']
- [digital_crc32_bb_0_1, '0', blocks_tagged_stream_mux_0_0_0_1_1, '1']
- [digital_crc32_bb_0_1, '0', digital_protocol_formatter_bb_0_0_0_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_protocol_formatter_bb_0_0_0, '0', blocks_tagged_stream_mux_0_0_0_1, '0']
- [digital_protocol_formatter_bb_0_0_0_0, '0', blocks_tagged_stream_mux_0_0_0_1_1, '0']
- [low_pass_filter_0_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_3, '0', blocks_repack_bits_bb_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_msgpair_to_var_0, inpair]
- [zeromq_sub_msg_source_0_0, out, blocks_msgpair_to_var_0_0, inpair]

metadata:
  file_format: 1
