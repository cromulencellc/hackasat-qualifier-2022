options:
  parameters:
    generate_options: qt_gui
    id: testsolver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: qpsk_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1'
    reference: '100'
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: float
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_0
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: network_tcp_source_0_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'False'
    type: complex
  states: {}
- name: pdu_pdu_split_0
  id: pdu_pdu_split
  parameters:
    pass_empty: 'False'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '10'
    type: complex
    xmax: '100'
    xmin: '-100'
    ymax: '100'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '5000'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [network_tcp_source_0_0, '0', analog_feedforward_agc_cc_0, '0']
- [network_tcp_source_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [pdu_pdu_split_0, vec, zeromq_push_msg_sink_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, pdu_pdu_split_0, pdu]

metadata:
  file_format: 1
